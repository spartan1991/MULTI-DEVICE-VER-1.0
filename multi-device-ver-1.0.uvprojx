# Keil uVision project multi-device-ver-1.0.uvprojx, settings and files
target source (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: multi-device-ver-1.0 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\LCD5110 (Driver AVR to STM);.\Screens;.\CMSIS\CM3\CoreSupport;.\STM32F10x_StdPeriph_Driver\inc;.\STM32F10x_StdPeriph_Driver\STM32F10x_StdPeriph_Template;.\CMSIS\CM3\DeviceSupport\ST\STM32F10x;.\CMSIS\CM3\DeviceSupport\ST\STM32F10x\startup\arm;.\Cpu-Init;.\Models;.\System
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group main
    ./Main/: main.c
  group screens
    ./Screens/: screens.c
  group lcd-driver
    ./LCD5110 (Driver AVR to STM)/: n3310.c
  group periph-driver
    ./STM32F10x_StdPeriph_Driver/src/: stm32f10x_adc.c stm32f10x_dma.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_exti.c misc.c
    ./STM32F10x_StdPeriph_Driver/STM32F10x_StdPeriph_Template/: stm32f10x_conf.h
  group cmsis-core
    ./CMSIS/CM3/CoreSupport/: core_cm3.c
  group startup
    ./CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_cl.s
    ./CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group cpu-init
    ./Cpu-Init/: cpu-init.c
  group models
    ./Models/: models.h
  group system
    ./System/: system.c
